# Keil uVision project LQ-STC&52-OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: LQ_OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LQ12864.c LQ12864main.c LQ12864.h stc.H
